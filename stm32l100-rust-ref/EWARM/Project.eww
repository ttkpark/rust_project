<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32l100-rust-ref.ewp</path>
  </project>
  <batchBuild />
</workspace>
